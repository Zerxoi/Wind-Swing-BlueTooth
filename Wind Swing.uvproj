# Keil uVision project Wind Swing.uvproj, settings and files
target Wind Swing (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Wind Swing +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Wind Swing
  group System
    ./: i2c.c m6050.c main.c pid.c ser_printf.c pwm.c timer0.c mathmod.c kalman.c motor.c bluetooth.c
